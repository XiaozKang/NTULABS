# Keil uVision project Lab2.uvproj, settings and files
target Lab2 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab2 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM
  c include: ..\Hardware;..\STM32F4xx_Driver\inc;..\CORE;..\FreeRTOS_CORE\include;..\FreeRTOS_PORTABLE;..\SYSTEM\sys;..\SYSTEM\delay
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./: main.c
  group CORE
    ../CORE/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group STM32F4xx_Driver
    ../STM32F4xx_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../STM32F4xx_Driver/inc/: stm32f4xx_usart.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: system.c sys.c
  group HARDWARE
    ../Hardware/: buzzer.c led.c oled.c show.c play_button.c uart.c uart.h led.h
  group FREERTOS
    ../FreeRTOS_CORE/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../FreeRTOS_PORTABLE/: heap_4.c port.c
    ../FreeRTOS_CORE/include/: FreeRTOSConfig.h
